require opensolo-image.inc
PROVIDES += "solo_drone"
IMAGE_INSTALL += "packagegroup-opensolo-solo"
export IMAGE_BASENAME = "3dr-solo"
