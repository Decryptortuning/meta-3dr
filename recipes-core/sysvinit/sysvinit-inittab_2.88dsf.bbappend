FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
# Machine-specific rc_mxc.S replaces the vendor generic source before install.
