# Placeholder: dtc 1.7.0 already pulls from kernel.org; add overrides here if needed.
