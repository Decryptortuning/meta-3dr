# Placeholder for Solo-specific kernel customizations on Scarthgap (linux-imx 6.6).
# Add config fragments/patches here when ready.
