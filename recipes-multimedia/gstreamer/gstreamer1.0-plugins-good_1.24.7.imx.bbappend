FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://CVE-2026-18649-rtp-fragment-bound.patch"
