# Placeholder append to hook meta-3dr into the Scarthgap gstreamer-good recipe.
# Extend here if project-specific config or patches are needed.
